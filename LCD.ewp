# IAR project LCD.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xB ST STM32F107xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; micrium\Micrium\Software\EvalBoards\Micrium\uC-Eval-STM32F107\IAR\BSP; micrium\Micrium\Software\EvalBoards\Micrium\uC-Eval-STM32F107\IAR\uCOS-III-Lib; micrium\Micrium\Software\EvalBoards\Micrium\uC-Eval-STM32F107\IAR\BSP\uCOS-III; micrium\Micrium\Software\EvalBoards\Micrium\uC-Eval-STM32F107\IAR\BSP\ST\STM32\INC; micrium\Micrium\Software\uC-LIB; micrium\Micrium\Software\uC-CPU; micrium\Micrium\Software\uC-CPU\ARM-Cortex-M3\IAR; micrium\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; micrium\Micrium\Software\uCOS-III\Source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LCD.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: micrium\Micrium\Software\EvalBoards\Micrium\uC-Eval-STM32F107\IAR\BSP\STM32_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group APP
    ./: app_vect.c const_data.h global_decls.h includes.h main.c
  group APP/CFG
    ./: app_cfg.h os_cfg_app.h
  group BSP
    ../../../../Micrium/Software/EvalBoards/Micrium/uC-Eval-STM32F107/IAR/BSP/: STM32_FLASH.icf
  group BSP/Headers
    micrium/Micrium/Software/EvalBoards/Micrium/uC-Eval-STM32F107/IAR/BSP/: bsp.h
    ./: bsp_spi_int.h
  group BSP/Source
    micrium/Micrium/Software/EvalBoards/Micrium/uC-Eval-STM32F107/IAR/BSP/: bsp.c bsp_int.c bsp_periph.c
  group BSP/STM32 Library/inc
    ../../../../Micrium/Software/EvalBoards/Micrium/uC-Eval-STM32F107/IAR/BSP/ST/STM32/INC/: cortexm3_macro.h stm32f10x_conf.h stm32f10x_dbgmcu.h stm32f10x_flash.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_rtc.h stm32f10x_systick.h stm32f10x_type.h
    micrium/Micrium/Software/EvalBoards/Micrium/uC-Eval-STM32F107/IAR/BSP/ST/STM32/INC/: stm32f10x_gpio.h stm32f10x_nvic.h stm32f10x_rcc.h stm32f10x_spi.h
  group BSP/STM32 Library/src
    micrium/Micrium/Software/EvalBoards/Micrium/uC-Eval-STM32F107/IAR/BSP/ST/STM32/SRC/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c
  group CFG - LIBRARIES
    micrium/Micrium/Software/EvalBoards/Micrium/uC-Eval-STM32F107/IAR/uCOS-III-Lib/: cpu_cfg.h lib_cfg.h os_cfg.h os_type.h
  group uC/CPU/Headers
    micrium/Micrium/Software/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h
    micrium/Micrium/Software/uC-CPU/: cpu_core.h cpu_def.h
  group uC/CPU/Library
    micrium/Micrium/Software/EvalBoards/Micrium/uC-Eval-STM32F107/IAR/uCOS-III-Lib/: uC-CPU-CM3-IAR.a
  group uC/LIB/Headers
    micrium/Micrium/Software/uC-LIB/: lib_ascii.h lib_def.h lib_math.h lib_mem.h lib_str.h
  group uC/LIB/Library
    micrium/Micrium/Software/EvalBoards/Micrium/uC-Eval-STM32F107/IAR/uCOS-III-Lib/: uC-LIB-CM3-IAR.a
  group uC/OS-III
    micrium/Micrium/Software/uCOS-III/Source/: os_cfg_app.c os_dbg.c
  group uC/OS-III/Headers
    micrium/Micrium/Software/uCOS-III/Source/: os.h os_type.h
    micrium/Micrium/Software/uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h
  group uC/OS-III/Library
    micrium/Micrium/Software/EvalBoards/Micrium/uC-Eval-STM32F107/IAR/uCOS-III-Lib/: uCOS-III-CM3-IAR.a
